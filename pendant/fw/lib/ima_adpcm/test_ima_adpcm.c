/* Host test: cc -std=c99 -Wall -Wextra -o /tmp/t test_ima_adpcm.c ima_adpcm.c && /tmp/t */
#include <assert.h>
#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include "ima_adpcm.h"

/* Measured 61 on the ±8000 triangle (2026-10-13). A regression past this fails. */
#define MAX_ERR 64

/* audioop.lin2adpcm (Python 3.9) of gen_input(), nibbles swapped to low-first */
static const uint8_t expected[256] = {
	0xff, 0xff, 0xff, 0xff, 0xff, 0x09, 0x08, 0x08, 0x77, 0x81, 0x80, 0x80, 0x80, 0x80, 0x80, 0x08,
	0xff, 0x09, 0x08, 0x08, 0x08, 0x08, 0x08, 0x80, 0x77, 0x81, 0x80, 0x80, 0x80, 0x80, 0x80, 0x08,
	0xff, 0x09, 0x08, 0x08, 0x08, 0x08, 0x08, 0x80, 0x77, 0x81, 0x80, 0x80, 0x80, 0x80, 0x80, 0x08,
	0xff, 0x09, 0x08, 0x08, 0x08, 0x08, 0x08, 0x80, 0x77, 0x81, 0x80, 0x80, 0x80, 0x80, 0x80, 0x08,
	0xaf, 0x08, 0x88, 0x91, 0x81, 0x88, 0xa1, 0xa2, 0x82, 0xb0, 0x20, 0x08, 0x80, 0x5a, 0xba, 0x20,
	0x98, 0xa2, 0xb3, 0x12, 0x78, 0xe0, 0x0a, 0x51, 0xe0, 0x30, 0x2a, 0x19, 0x4b, 0x0b, 0x58, 0x09,
	0x3c, 0x0b, 0x28, 0x6c, 0x89, 0x28, 0xc8, 0x10, 0xe3, 0x08, 0xb4, 0xb4, 0x83, 0x2a, 0x2a, 0x1d,
	0x80, 0x89, 0x83, 0x99, 0x11, 0x98, 0xb7, 0x30, 0x5d, 0xc0, 0x80, 0xa2, 0x98, 0xa7, 0x29, 0x93,
	0xc7, 0x4f, 0x50, 0x8d, 0x31, 0x8f, 0x48, 0x08, 0x2c, 0x31, 0x89, 0x3f, 0x81, 0x6c, 0x3e, 0x90,
	0xe0, 0xb7, 0x69, 0xad, 0x81, 0x68, 0xc8, 0x87, 0x80, 0x9f, 0x24, 0xf0, 0x83, 0x80, 0x09, 0x2e,
	0x6a, 0x2c, 0xc4, 0x39, 0xc2, 0x69, 0xac, 0x78, 0x2a, 0x5c, 0x89, 0xb0, 0x50, 0x1f, 0x10, 0x6b,
	0x0c, 0xa6, 0x11, 0x09, 0xaf, 0x95, 0x92, 0xf2, 0x08, 0xb1, 0x17, 0x80, 0xba, 0x21, 0xa4, 0x3a,
	0xcc, 0xc7, 0xd5, 0x49, 0x0b, 0x08, 0xc7, 0xa1, 0x82, 0x85, 0xe1, 0xc3, 0x38, 0x28, 0x0f, 0x41,
	0x88, 0x5d, 0xc9, 0x12, 0x10, 0x01, 0xbf, 0xc6, 0x92, 0x09, 0x20, 0x4c, 0x82, 0x1d, 0x7b, 0x19,
	0x0f, 0x86, 0xc1, 0x00, 0x4a, 0x9c, 0x15, 0xa9, 0xd0, 0x82, 0x85, 0x4b, 0x2d, 0xd3, 0x93, 0xb0,
	0xa6, 0x80, 0x09, 0xd7, 0xa5, 0x00, 0x01, 0x3f, 0xe0, 0x28, 0x79, 0x8d, 0x94, 0x28, 0x1c, 0x69,
};
/* Sum of audioop.adpcm2lin output; reference final state is pred=30803, index=88. */
#define EXPECTED_DEC_SUM 336369LL

/* Same integer generator as the vector script: square ±30000, small noise, full-scale noise. */
static void gen_input(int16_t *pcm, int n)
{
	uint32_t x = 1;

	for (int i = 0; i < n; i++) {
		x = x * 1103515245u + 12345u;
		if (i < 128) {
			pcm[i] = (i / 16) % 2 ? 30000 : -30000;
		} else if (i < 256) {
			pcm[i] = (int)((x >> 16) & 0x0fff) - 2048;
		} else {
			pcm[i] = (int)((x >> 16) & 0xffff) - 32768;
		}
	}
}

/* 100 Hz triangle at 8 kHz, ±8000: voice-band level and slope. */
static void gen_triangle(int16_t *pcm, int n)
{
	for (int i = 0; i < n; i++) {
		int t = i % 80;

		pcm[i] = (t < 40 ? t : 80 - t) * 400 - 8000;
	}
}

int main(void)
{
	struct ima_adpcm s;
	int16_t pcm[512], dec[512], dec2[256];
	uint8_t enc[256];
	long long sum = 0;

	/* 1. Bit-exact with the reference encoder and decoder. */
	gen_input(pcm, 512);
	ima_adpcm_reset(&s);
	ima_adpcm_encode(&s, pcm, 512, enc);
	assert(memcmp(enc, expected, sizeof(enc)) == 0);
	assert(s.pred == 30803 && s.index == 88);
	ima_adpcm_reset(&s);
	ima_adpcm_decode(&s, enc, 512, dec);
	for (int i = 0; i < 512; i++) {
		sum += dec[i];
	}
	assert(sum == EXPECTED_DEC_SUM);

	/* 2. 4 bit/sample: 8000 samples/s -> 4000 B/s = 32 kbps. Odd counts round up. */
	assert(ima_adpcm_bytes(8000) * 8 == 32000);
	assert(ima_adpcm_bytes(3) == 2);

	/* 3. Round-trip error bound on a voice-band signal after warm-up. */
	gen_triangle(pcm, 512);
	ima_adpcm_reset(&s);
	ima_adpcm_encode(&s, pcm, 512, enc);
	ima_adpcm_reset(&s);
	ima_adpcm_decode(&s, enc, 512, dec);
	int max_err = 0;
	for (int i = 32; i < 512; i++) {
		int e = abs(dec[i] - pcm[i]);
		max_err = e > max_err ? e : max_err;
	}
	printf("triangle max |err| after 32 samples: %d\n", max_err);
	assert(max_err <= MAX_ERR);

	/* 4. With a reset at the chunk boundary, chunk 2 decodes on its own. */
	ima_adpcm_reset(&s);
	ima_adpcm_encode(&s, pcm, 256, enc);
	ima_adpcm_reset(&s);
	ima_adpcm_encode(&s, pcm + 256, 256, enc + 128);
	ima_adpcm_reset(&s);
	ima_adpcm_decode(&s, enc + 128, 256, dec2);
	ima_adpcm_reset(&s);
	ima_adpcm_decode(&s, enc, 256, dec);
	ima_adpcm_reset(&s);
	ima_adpcm_decode(&s, enc + 128, 256, dec + 256);
	assert(memcmp(dec + 256, dec2, sizeof(dec2)) == 0);
	/* Without the reset, chunk 2 would start from chunk 1's state and differ. */
	ima_adpcm_decode(&s, enc + 128, 256, dec2);
	assert(memcmp(dec + 256, dec2, sizeof(dec2)) != 0);

	puts("ima_adpcm: all tests passed");
	return 0;
}
