# Repository KanadeSisido/ecapa-tdnn-quantized (continued)

## KiCad design pendant/hw/standard/standard.kicad_pcb

File pendant/README.md:

# anam ペンダント（ハードウェア）

日常の音声を、長時間・低消費電力で記録する小型ペンダント型ロガー。アプリと全体の説明は[リポジトリの README](../README.md)。

```text
録音 → 本体の NAND に蓄積 → 約 2 時間ごとにスマートフォンへ BLE でバースト同期
```

リアルタイム性は要求しない。スマホが無い間は同期をスキップし、蓄積を続ける。スマホの不在は異常ではなく、通常の状態として扱う。録音・保存・通信・発電は互いに独立させ、1 つの故障を他へ波及させない。

状態: 試作の段階。仕様は **確定 / 方針 / 仮置き** で確度を書き分けている（各ファイルの冒頭に凡例）。電力・音声・RF の成立は未検証で、実測で決める項目は各仕様の「未確定」に issue 番号つきで並べている。

## 2 つの製品（SKU）

Bluetooth の構成は同じ。差は電源・保存・筐体だけ。

| | Standard | Premium |
|---|---|---|
| スマホ | 必携（不在中は buffer の容量まで） | 不在でも 48 h まで録音を保証 |
| 電源 | CR2477 × 1（ユーザー交換、約 1 年が目標） | Solar + 120 F HSL + 非常用 CR2032 |
| 保存 | 1.8 V 生 SPI NAND 512 Mbit〜1 Gbit | 1.8 V 生 SPI NAND 4 Gbit 基準 |
| 外形の目標 | φ40〜42 mm、厚さ 15 mm 以内 | φ40〜42 mm、厚さ 18〜22 mm 級 |

どちらも、前面が押せるボタン、電源が尽きると黒に反転する赤 / 黒の終端表示フラグ、物理の privacy latch を持つ。**2026 年 11 月中旬のハッカソンに向け、Premium の試作を共通コアと並行して先行する。Solar・外観・非常用ボタン電池を必須とし、USB 給電は設けない。**

上の表は製品目標。**11 月のデモ機は短時間の録音を優先し、512 Mbit NAND を設計採用する。48 h のオフライン保存はデモ機の対象外**とする。実機の保存・電源時間は未検証。

## 構成（概要）

```text
Standard  CR2477 ─ reservoir ───────────────────────────┐
Premium   Solar → BQ25505 ↔ 120 F HSL → VSTOR ─ mux ───┤→ TPS62840 → 1.8 V rail
                  CR2032 ─ 一次電池逆流保護 ──── mux ───┘
                                              │
              ┌───────────────────────────────┼──────────────┐
        nRF54L15（Fanstel BC15M）       T5848 I²S マイク    1.8 V SPI NAND
        MCU + BLE + 内蔵アンテナ        + AAD               append-only ring
```

- 録音: I²S（16 kHz）→ 8 kHz mono → IMA-ADPCM 32 kbps（AAD で音があるときだけ）。Premium 製品は空きが減ると 16 kbps 級へ縮退する方針。11 月デモは縮退なしの 32 kbps を使う。
- 保存: ファイルシステム無し。耐電断の append-only ring。通常はスマホが ACK した範囲を解放し、満杯時は最古を破棄して欠落を通知する方針。
- 同期: 短い advertise の後に、累積 ACK 付きでバースト転送。送信は +4 dBm 以下。
- 更新: 出荷前に MCUboot を書き、以降はスマホから BLE DFU。SWD は開発と救済用。
- 安全: LESC + OOB、広告に機器名を載せない、保存データを暗号化する。
- 開発用の MCU は XIAO nRF54L15。製品の基板は Fanstel BC15M を自宅でリフロー実装する。

## ドキュメント

今の仕様は `docs/spec/`。

| パス | 内容 |
|---|---|
| [docs/spec/product.md](docs/spec/product.md) | 目的・要求、Standard / Premium の分岐、UX、BOM、全体の目標 |
| [docs/spec/power.md](docs/spec/power.md) | 電源パス、しきい値と状態機械、brownout、エネルギー収支、OTA の電力条件 |
| [docs/spec/terminal-indicator.md](docs/spec/terminal-indicator.md) | 赤 / 黒の終端表示（電源ゼロで保持） |
| [docs/spec/storage.md](docs/spec/storage.md) | NAND の選定、ring、耐電断、バックログ連動ビットレート |
| [docs/spec/audio.md](docs/spec/audio.md) | マイク、音響、AAD、codec、縮退モード、ASR の評価方法 |
| [docs/spec/formats.md](docs/spec/formats.md) | レコード形式、時刻補正、BLE 同期、ACK |
| [docs/spec/firmware.md](docs/spec/firmware.md) | OTA・MCUboot・パーティション、watchdog、時刻管理、`fw/lib` の対応表 |
| [docs/spec/security.md](docs/spec/security.md) | 脅威モデル、ペアリング、鍵、暗号化、デバッグ保護 |
| [docs/spec/rf.md](docs/spec/rf.md) | アンテナ、整合、RF の ESD、送信電力、RF 試験 |
| [docs/spec/board.md](docs/spec/board.md) | ピン割当、test point、測定リンク、配置・ESD・EMI の規則 |
| [docs/spec/mechanical.md](docs/spec/mechanical.md) | 筐体、汗・防水、Solar ボタン、積層 |
| [docs/test/](docs/test/) | 試験・測定の固定仕様（INA228 の電流測定治具） |

調査ログ・価格の調査・測定結果・未決の問いは、GitHub の issue に置く。仕様の「未確定」の表が、該当する issue を指す。

## リポジトリの構成

```text
fw/      Zephyr / NCS のファームウェア（nRF54L15、sysbuild + MCUboot）
  lib/     純 C のライブラリ（ホストで試験できる）。aad、bitrate、chunk、ima_adpcm、
           powerstate、ring、rtc、sync、t5838 など。`make -C fw/lib test`
  src/     アプリ（録音、BLE、OTA、時刻、supervisor）
  boards/  パーティションと board overlay
hw/      基板（KiCad）。Standard 基板は hw/standard/
tools/   PC 側のツール（Python / C）: 受信 `pendant_rx.py`、OTA `ota.py`、
           電力と reservoir の計算、ASR 評価、BQ25505 の抵抗計算
docs/    仕様・計画・決定ログ・試験・archive
```

コードのコメントは `docs/spec/<ファイル> §n` の形で、根拠の節を指す。仕様を変えるときは、その節も一緒に直す。

Parts:
BT1: CR2477; BatteryHolder_MYOUNG_MY-2477-01; MPN MYOUNG MY-2477-01 (LCSC C2979173)
C1: 100u; C_0805_2012Metric; MPN Murata GRM21BR60J107ME15L
C2: 220u; C_1206_3216Metric; MPN Murata GRM31CR60J227ME11L; not fitted
C3, C5: 4.7u; C_0402_1005Metric; MPN Murata GRM155R61A475MEAAD
C4: 10u; C_0402_1005Metric; MPN YAGEO CC0402MRX5R4BB106
C6, C10, C11, C12: 100n; C_0402_1005Metric
C9: 4.7u; C_0402_1005Metric
C13: 10n; C_0402_1005Metric
C14: 100n; C_0402_1005Metric; not fitted
C15: TBD; C_1206_3216Metric; not fitted
D1, D2, D3: Schottky; D_SOD-323; not fitted
J1: SWD pogo; SWD_Pogo_2x03_P1.27mm_NoHoles
L1: 2.2u; L_Murata_DFE201610P; MPN Murata DFE201612E-2R2M=P2 (2016; land o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
R1: 0R R_BAT; R_0402_1005Metric
R2, R3, R10, R11, R12, R15: 0R; R_0402_1005Metric
R4: 0R R_MAIN; R_0402_1005Metric
R5, R13, R17, R18, R19: 1M; R_0402_1005Metric
R6: 0R R_NAND; R_0402_1005Metric
R7, R8, R9, R26: 100k; R_0402_1005Metric
R14: 0R R_MIC; R_0402_1005Metric
R16: 0R; R_0402_1005Metric; not fitted
R20: 0R R_RTC; R_0402_1005Metric; not fitted
R21, R22, R23, R24: 10k; R_0402_1005Metric; not fitted
R25: 1M; R_0402_1005Metric; not fitted
SW1: PRIVACY; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
SW2: B3U-1000P; SW_SPST_B3U-1000P
TP1: VBAT; TestPoint_Pad_D1.0mm
TP2: VBAT_SYS; TestPoint_Pad_D1.0mm
TP3: 1V8_BUCK; TestPoint_Pad_D1.0mm
TP4: 1V8; TestPoint_Pad_D1.0mm
TP5: NAND_1V8; TestPoint_Pad_D1.0mm
TP6: MIC_1V8; TestPoint_Pad_D1.0mm
TP7, TP8: GND; TestPoint_Pad_D1.0mm
TP12: UART_TX; TestPoint_Pad_D1.0mm
TP13: UART_RX; TestPoint_Pad_D1.0mm
TP14: MK_REC; TestPoint_Pad_D1.0mm
TP15: MK_STORE; TestPoint_Pad_D1.0mm
TP16: MK_BLE; TestPoint_Pad_D1.0mm
TP17: VBAT_ADC; TestPoint_Pad_D1.0mm
TP18: IND_A; TestPoint_Pad_D1.0mm
TP19: IND_B; TestPoint_Pad_D1.0mm
TP20: MIC_1V8_PRE; TestPoint_Pad_D1.0mm
U1: LM66100DCK; SOT-363_SC-70-6; not fitted
U2: TPS62840DLCR; Texas_VSON-HR-8_1.5x2mm_P0.5mm
U3: BC15M; Fanstel_BC15M; MPN Fanstel BC15M (nRF54L15, 技適 201-250527)
U4, U6, U9: TPS22917DBVR; SOT-23-6
U5: F35UQA512M-WWR; WSON-8-1EP_8x6mm_P1.27mm_EP3.4x4.3mm
U7: SN74AUP3G34DCUR; VSSOP-8_2.3x2mm_P0.5mm
U8: MMICT5848-00-012; TDK_T5848_LGA-8_3.5x2.65mm
U10: RV-3032-C7; MicroCrystal_C7_SON-8_1.5x3.2mm_P0.9mm; not fitted
U11: TPS3840PH (TBD); SOT-23-5; not fitted
U12: DRV8837DSGR; Texas_DSG0008A_WSON-8-1EP_2x2mm_P0.5mm_EP0.9x1.6mm; not fitted

Connections:
1V8: C5.1, C6.1, J1.1 (VCC), R4.2, R20.1, TP4.1 (1_1), U3.F6 (VDD), U4.1 (VIN), U6.1 (VIN)
/BATSENSE_EN: R17.1, U3.B1 (P1.08), U9.3 (ON)
/BTN: SW2.1, U3.B4 (P1.07/AIN3)
/I2C_SCL: R23.1, U3.D5 (P1.11), U10.8 (SCL)
/I2C_SDA: R22.1, U3.D2 (P1.10), U10.2 (SDA)
/I2S_SCK_MCU: U3.D1 (P1.12), U7.1 (1A)
/I2S_WS_MCU: U3.F4 (P1.03/NFC2), U7.3 (2A)
/MIC_EN: R13.1, U3.C4 (P2.00), U6.3 (ON)
/MIC_SD: R26.1, U3.E2 (P1.13), U8.8 (SD)
/MIC_WAKE: U3.D4 (P1.14), U8.4 (WAKE)
/MK_BLE: TP16.1 (1_1), U3.D3 (P2.08)
/MK_REC: TP14.1 (1_1), U3.F2 (P2.06)
/MK_STORE: TP15.1 (1_1), U3.B3 (P2.07)
/NAND_CS: R9.1, U3.A6 (P2.05), U5.1 (~CS)
/NAND_MISO_MCU: R12.2, U3.F5 (P2.04)
/NAND_MOSI_MCU: R11.1, U3.D6 (P2.02)
/NAND_SCK_MCU: R10.1, U3.C6 (P2.01)
/SWCLK: J1.4 (SWCLK), U3.A4 (SWDCLK)
/SWDIO: J1.2 (SWDIO), U3.A3 (SWDIO)
/THSEL_MCU: U3.C3 (P1.09), U7.6 (3A)
/UART_RX: TP13.1 (1_1), U3.A1 (P0.01)
/UART_TX: TP12.1 (1_1), U3.A2 (P0.00)
/VBAT_ADC: C13.1, R18.2, R19.1, TP17.1 (1_1), U3.C5 (P1.04/AIN0)
/nRESET: J1.3 (~RESET), U3.F3 (~RESET)
GND: BT1.2 (-), C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, J1.5 (GND), R5.2, R13.2, R15.2, R17.2, R19.2, R21.2, R25.2, R26.2, SW2.2, TP7.1 (1_1), TP8.1 (1_1), U1.2 (GND), U1.3 (~CE), U2.1 (GND), U2.3 (MODE), U2.5 (VSET), U2.6 (STOP), U3.E1 (GND), U3.F1 (GND), U4.2 (GND), U5.4 (GND), U6.2 (GND), U7.4 (GND), U8.3 (GND), U9.2 (GND), U10.5 (VSS), U11.3 (GND), U12.4 (GND), U12.9 (GND)
MIC_1V8: C11.1, C12.1, R16.2, SW1.2 (B), TP6.1 (1_1), U7.8 (VCC), U8.7 (VDD)
NAND_1V8: C9.1, C10.1, R6.2, R7.2, R8.2, R9.2, TP5.1 (1_1), U5.8 (VCC)
unnamed: D1.2 (A), R24.2
unnamed: D2.2 (A), U11.1 (OUT), U12.5 (IN2)
unnamed: D2.1 (K), D3.1 (K), R25.1, U12.7 (~SLEEP)
unnamed: D3.2 (A), U3.A5 (P2.09), U12.6 (IN1)
unnamed: R14.2, SW1.1 (A), TP20.1 (1_1)
unnamed: R1.2, R2.1, U1.1 (VIN)
unnamed: R3.2, U2.4 (EN)
unnamed: L1.1, U2.7 (SW)
unnamed: C4.1, L1.2, R4.1, TP3.1 (1_1), U2.8 (VOS)
unnamed: R5.1, U3.E4 (P2.03), U4.3 (ON)
unnamed: R6.1, U4.5 (QOD), U4.6 (VOUT)
unnamed: R10.2, U5.6 (CLK)
unnamed: R11.2, U5.5 (DI/SIO0)
unnamed: R12.1, U5.2 (DO/SIO1)
unnamed: R8.1, U5.7 (~HOLD/SIO3)
unnamed: R7.1, U5.3 (~WP/SIO2)
unnamed: R14.1, U6.6 (VOUT)
unnamed: U7.7 (1Y), U8.6 (SCK)
unnamed: U7.5 (2Y), U8.1 (WS)
unnamed: U7.2 (3Y), U8.5 (THSEL)
unnamed: R15.1, R16.1, U8.2 (LR)
unnamed: R18.1, U9.6 (VOUT)
unnamed: R21.1, U10.1 (VBACKUP)
unnamed: TP18.1 (1_1), U12.2 (OUT1)
unnamed: TP19.1 (1_1), U12.3 (OUT2)
RTC_VDD: C14.1, R20.2, R22.2, R23.2, U10.6 (VDD)
VBAT: BT1.1 (+), R1.1, TP1.1 (1_1)
VBAT_SYS: C1.1, C2.1, C3.1, R2.2, R3.1, R24.1, TP2.1 (1_1), U1.6 (VOUT), U2.2 (VIN), U9.1 (VIN), U11.2 (VDD)
VLG: C15.1, D1.1 (K), U12.1 (VM), U12.8 (VCC)

Notes on the sheet:
電源入力・逆流防止（DNP）・reservoir
1.8 V 降圧（TPS62840）
モジュール（Fanstel BC15M）・SWD・テストポイント
NAND（電源ゲート + SPI）
マイク（電源ゲート・privacy latch・Ioff バッファ・T5848）
電池電圧の測定・前面ボタン
RTC（footprint のみ・DNP）
終端表示（仮・DNP）
PWR_FLAG（ERC 用）

Board: 2 copper layers, 30.0 x 30.0 mm, 76 parts (1 on the bottom side), 56 nets.

File pendant/hw/standard/fab/bom_jlc.csv:

Comment,Designator,Footprint,LCSC Part #,Quantity per board,Manufacturer Part #,Other supplier
1.8 V buck,U2,Texas_VSON-HR-8_1.5x2mm_P0.5mm,C2071859,1,TPS62840DLCR,
Load switch,"U4,U6,U9",SOT-23-6,C2681320,3,TPS22917DBVR,
Triple buffer (Ioff),U7,VSSOP-8_2.3x2mm_P0.5mm,,1,SN74AUP3G34DCUR,DigiKey JP 296-25595-1-ND
2.2 uH 2016,L1,L_Murata_DFE201610P (2016),C337893,1,DFE201612E-2R2M=P2,
Tact switch,SW2,SW_SPST_B3U-1000P,C231329,1,B3U-1000P,
CR2477 clip,BT1,BatteryHolder_MYOUNG_MY-2477-01 (THT),C2979173,1,MY-2477-01,
100 uF 0805 6.3 V X5R,C1,C_0805_2012Metric,C141660,1,GRM21BR60J107ME15L,
4.7 uF 0402 10 V X5R,"C3,C5,C9",C_0402_1005Metric,C335105,3,GRM155R61A475MEAAD,
10 uF 0402 6.3 V X5R,C4,C_0402_1005Metric,C15525,1,CL05A106MQ5NUNC,
100 nF 0402 X7R,"C6,C10,C11,C12",C_0402_1005Metric,C60474,4,CC0402KRX7R7BB104,
10 nF 0402 X7R,C13,C_0402_1005Metric,C15195,1,CL05B103KB5NNNC,
0 ohm 0402,"R1,R2,R3,R4,R6,R10,R11,R12,R14,R15",R_0402_1005Metric,C17168,10,0402WGF0000TCE,
1 Mohm 0402 1%,"R5,R13,R17,R18,R19",R_0402_1005Metric,C26083,5,0402WGF1004TCE,
100 kohm 0402 1%,"R7,R8,R9,R26",R_0402_1005Metric,C25741,4,0402WGF1003TCE,
BLE module nRF54L15,U3,Fanstel_BC15M (LGA-36),,1,Fanstel BC15M,DigiKey JP 1914-BC15MCT-ND
SPI NAND 512 Mbit 1.8 V,U5,WSON-8-1EP_8x6mm_P1.27mm,,1,F35UQA512M-WWR,DigiKey JP 5110-F35UQA512M-WWRCT-ND
I2S mic (AAD),U8,TDK_T5848_LGA-8_3.5x2.65mm,,1,MMICT5848-00-012,DigiKey JP 1428-MMICT5848-00-012CT-ND
